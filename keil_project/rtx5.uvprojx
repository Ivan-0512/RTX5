# Keil uVision project rtx5.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: out +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\application;..\driver;..\core
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../application/: main.c
  group Driver
    ../driver/: led.c spi_led.c
  group Core
    ../core/: utility.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:GD32E23x_StdPeripherals:ADC 1.0.0, Device:GD32E23x_StdPeripherals:CMP 1.0.0, Device:GD32E23x_StdPeripherals:CRC 1.0.0, Device:GD32E23x_StdPeripherals:DBG 1.0.0, Device:GD32E23x_StdPeripherals:DMA 1.0.0, Device:GD32E23x_StdPeripherals:EXTI 1.0.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:FWDGT 1.0.0, Device:GD32E23x_StdPeripherals:GPIO 1.0.0, Device:GD32E23x_StdPeripherals:I2C 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:PMU 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_StdPeripherals:RTC 1.0.0, Device:GD32E23x_StdPeripherals:SPI_I2S 1.0.0, Device:GD32E23x_StdPeripherals:SYSCFG 1.0.0, Device:GD32E23x_StdPeripherals:TIMER 1.0.0, Device:GD32E23x_StdPeripherals:USART 1.0.0, Device:GD32E23x_StdPeripherals:WWDGT 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:Startup 1.0.0
